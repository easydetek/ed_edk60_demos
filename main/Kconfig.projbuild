## sdkconfig.defaults.esp32c6
```kconfig
# 由 build_all.ps1 自动生成 —— 请勿手工编辑，改动会被下一次构建覆盖。
# 当前 demo 选择：APP_EDK60_DEMO_RADAR_BRIDGE_EDV163_GESTURE
CONFIG_APP_EDK60_DEMO_RADAR_BRIDGE_EDV163_GESTURE=y
```
